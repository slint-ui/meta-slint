require recipes-slint/slint/slint-cpp.inc

# v1.0.2 tag
SLINT_REV = "b5d0b6552e83ab09bca853f5c296d06239c19630"
