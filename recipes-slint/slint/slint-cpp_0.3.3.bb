require recipes-slint/slint/slint-cpp.inc

#TODO Update to real 0.3.3 release

SLINT_REV = "aea216fb492f9892f89fdd2764ecd98d019e6cdd"