require recipes-slint/slint/slint-cpp.inc

# v0.3.4 tag
SLINT_REV = "cfe43e84e31401d725cb0d25ac6e5999fde3a900"
