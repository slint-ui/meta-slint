require recipes-slint/slint/slint-cpp.inc

# v1.0.0 tag
SLINT_REV = "8df41a37cba4241c284b626ab8f81aca439d6cf9"
